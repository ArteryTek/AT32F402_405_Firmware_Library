# Keil uVision project run_in_qspi_flash.uvprojx, settings and files
target run_in_qspi_flash (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: AT32F402RCT7 ArteryTek
  pack: ArteryTek.AT32F402_405_DFP.2.1.3
  cpu: IRAM(0x20000000,0x19800) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: run_in_qspi_flash +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F402RCT7,USE_STDPERIPH_DRIVER,AT_START_F402_V1
  c include: ..\..\..\..\..\..\libraries\drivers\inc;..\..\..\..\..\..\libraries\cmsis\cm4\core_support;..\..\..\..\..\..\libraries\cmsis\cm4\device_support;..\..\..\..\..\at32f402_405_board;..\inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT5: ROM 0x90000000 size 0x1000000
  memory RVCT9: RAM 0x20000000 size 0x19800
  group user
    ../src/: at32f402_405_clock.c at32f402_405_int.c run_in_qspi.c main.c
  group bsp
    ../../../../../at32f402_405_board/: at32f402_405_board.c
  group firmware
    ../../../../../../libraries/drivers/src/: at32f402_405_crm.c at32f402_405_flash.c at32f402_405_gpio.c at32f402_405_misc.c at32f402_405_pwc.c at32f402_405_qspi.c at32f402_405_scfg.c at32f402_405_usart.c
  group cmsis
    ../../../../../../libraries/cmsis/cm4/device_support/: system_at32f402_405.c
    ../../../../../../libraries/cmsis/cm4/device_support/startup/mdk/: startup_at32f402_405.s
  group readme
    ../: readme.txt
